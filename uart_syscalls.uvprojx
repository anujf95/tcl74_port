# Keil uVision project uart_syscalls.uvprojx, settings and files
target uart_syscall (ARM-GNU)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_syscalls
  group src
    ./src/: main.c tm4c123gh6pm_startup_ccs_gcc.c uart_stream.c custom.c Nokia5110.c
    ./tcl74/: tclAppInit.c
  group tivalib
    ./tivalib/: gpio.c systick.c uart.c delay.c nvic.c
  group syscall
    ./syscall/: syscalls.c posix_syscalls.c
  group tcl74
    ./tcl74/: panic.c regexp.c tclAsync.c tclBareAZ.c tclBareStr.c tclBareUtil.c tclBasic.c tclCkalloc.c tclCmdAH.c tclCmdIL.c tclCmdMZ.c tclEnv.c tclExpr.c tclGet.c tclGlob.c tclHash.c tclHistory.c tclLink.c tclMain.c tclMtherr.c tclParse.c tclProc.c tclUtil.c tclVar.c
  group efs
    ./efs/: efs.c efs_ll.c
